# IAR project template.ewp, settings and files
configuration sbl (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: sbl.out
  ILINK.IlinkIcfFile: ..\board\link\LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ..\device\LPC55S69\iar\iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
